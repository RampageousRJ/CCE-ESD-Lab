
	AREA RESET, DATA, READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA code1, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R1,=SRC
	LDR R9,=DST
	LDR R8,=DST
	MOV R10,#8
	EXPORT INSERT
	
INSERT
	LDR R3,[R1],#4
	STR R3,[R9],#4
	SUB R10,R10,#1
	TEQ R10,#0
	BNE INSERT
	MOV R10,#4
	LDR R9,=DST+(4*7)
	
SWAP
	LDR R3,[R8]
	LDR R4,[R9]
	STR R4,[R8],#4
	STR R3,[R9],#-4
	SUB R10,R10,#1
	TEQ R10,#0
	BNE SWAP
	
STOP
	B STOP
	
SRC DCD 1,2,3,4,5,6,7,8	
	AREA data1, DATA, READWRITE

DST DCD 0
VAL DCD 0

	END