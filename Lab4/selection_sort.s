	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA myCode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
	

Reset_Handler
	MOV R10,#10
	LDR R12,=SRC
	LDR R0,=DST

STORE
	LDR R11,[R12],#4
	STR R11,[R0],#4
	SUB R10,R10,#1
	CMP R10,#0
	BNE STORE
	MOV R10,#10
	LDR R12,=DST
	LDR R1,=DST
	B LOOP1

LOOP1
	MOV R7,R1
	LDR R2,[R1],#4
	MOV R3,R1
	MOV R9,R10
	SUB R9,R9,#1
	CMP R9,#0
	BEQ FINAL
	B LOOP2
	B REST
	

LOOP2
	MOV R8,R3
	LDR R4,[R3],#4
	CMP R4,R2
	BLT SWAP
	B REST2
	
SWAP 
	MOV R0,R2
	MOV R5,R4
	MOV R2,R5
	MOV R4,R0
	STR R2,[R7]
	STR R4,[R8]

REST2
	SUB R9,R9,#1
	CMP R9,#0
	BNE LOOP2

REST
	SUB R10,R10,#1
	STR R2,[R12],#4
	CMP R10,#0
	BNE LOOP1
	
FINAL 
	STR R2,[R12],#4
	B STOP

STOP
	B STOP
	
SRC DCD 255,42,23,11,81,19,100,2,78,44

	AREA data1,DATA,READWRITE
DST DCD 0

	END