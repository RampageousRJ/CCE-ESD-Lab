	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA myCode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	MOV R0,#10
	LDR R1,=Num1
	LDR R2,[R1]
	LDR R1,=DST
	LDR R3,=SRC
	
LOOP
	LDR R4,[R3],#4
	CMP R4,R2
	BEQ FOUND
	SUB R0,R0,#1
	CMP R0,#0
	BNE LOOP
	MOV R4,#-1
	STR R4,[R1]
	B STOP

FOUND
	MOV R2,#10
	SUB R0,R2,R0
	STR R0,[R1]
	
STOP
	B STOP

Num1 DCD 23
SRC DCD 255,42,23,11,81,19,100,2,78,44

	AREA data1,DATA,READWRITE
DST DCD 0


	END