	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10004000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,=NUM
	LDR R1,=DST
	LDR R10,[R0]
	MOV R2,#0
	BL HEX2BCD
	STR R6,[R1]

STOP
	B STOP

HEX2BCD	CMP R10,#0
	BEQ DONE
	BL DIV
	LSL R10,R2
	ADD R6,R10
	ADD R2,#4
	MOV R10,R3
	MOV R3,#0
	B HEX2BCD

DONE
	STR R6,[R1]
	B STOP

DIV CMP R10,#0x0A
	BLO EXIT
	SUB R10,#0x0A
	ADD R3,#1
	B DIV
EXIT BX LR

NUM DCD 0xFF
	AREA DATASEG,DATA,READWRITE
DST DCD 0x0
	END