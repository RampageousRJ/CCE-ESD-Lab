	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA palindrome,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,=SRC
	LDR R1,[R0]
	MOV R2,R1
	MOV R12,#8
	MOV R0,#0xF
	MOV R3,#0
	
REVERSE
	AND R4,R2,R0
	MOV R2,R2,LSR #4
	MOV R3,R3,LSL #4
	ADD R3,R3,R4
	SUB R12,R12,#1
	CMP R12,#0
	BNE REVERSE
	B CHECK

CHECK 
	CMP R1,R3
	BEQ EQUAL
	BNE NOT_EQUAL

EQUAL
	LDR R1,=DST
	MOV R2,#1
	STR R2,[R1]
	B STOP
	
NOT_EQUAL
	LDR R1,=DST
	MOV R2,#-1
	STR R2,[R1]

STOP
	B STOP
	
SRC DCD 0x12300320

	AREA dataseg,DATA,READWRITE
DST DCD 0
	
	END