	AREA RESET,DATA,READONLY
	EXPORT __Vectors

__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA bitwise_palindrome,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R0,=SRC
	LDR R1,[R0]
	LDR R2,=0x00000080
	LDR R3,=0
	MOV R0,#8
	BL CONVERT
	BL PALINDROME
	
EXIT
	POP {R14}
	BX LR

CONVERT
	PUSH {R14}
	CMP R1,R2
	BHI HIGH
	BEQ HIGH
	BLO SECOND

HIGH
	ADD R3,R3,#1
	SUB R1,R1,R2

SECOND
	SUB R0,R0,#1
	CMP R0,#0
	BEQ EXIT
	MOV R3,R3,LSL #4
	MOV R2,R2,LSR #1
	B CONVERT
	
PALINDROME
	PUSH {R14}
	MOV R0,#8
	MOV R4,R3
	MOV R5,#0
	BL REVERSE
	MOV R0,#8
	BL CHECK
	B STOP
	
REVERSE
	PUSH {R14}
	AND R6,R4,#0xF
	ADD R5,R5,R6
	SUB R0,R0,#1
	CMP R0,#0
	BEQ EXIT
	MOV R5,R5,LSL #4
	MOV R4,R4,LSR #4
	B REVERSE
	
CHECK 
	PUSH {R14}
	AND R7,R3,#0xF
	AND R8,R5,#0xF
	CMP R7,R8
	BNE NPAL
	MOV R3,R3,LSR #4
	MOV R5,R5,LSR #4
	SUB R0,R0,#1
	CMP R0,#0
	BEQ SUCCESS
	B CHECK
	
SUCCESS
	LDR R0,=DST
	LDR R1,=0x1
	STR R1,[R0]
	B EXIT
	
NPAL 
	LDR R0,=DST
	LDR R1,=-1
	STR R1,[R0]
	B EXIT
	
STOP
	B STOP

SRC DCD 128

	AREA dseg,DATA,READWRITE
DST DCD 0

	END