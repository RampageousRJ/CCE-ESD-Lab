	AREA RESET,DATA,READONLY
	EXPORT __Vectors

__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA hex_to_binary,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R0,=SRC
	LDR R1,[R0]
	LDR R2,=0x00000080
	LDR R3,=0
	MOV R0,#8
	BL CONVERT
	B STOP
	
EXIT
	POP {R14}
	BX LR

CONVERT
	PUSH {R14}
	CMP R1,R2
	BHI HIGH
	BEQ HIGH
	BLO SECOND

HIGH
	ADD R3,R3,#1
	SUB R1,R1,R2

SECOND
	SUB R0,R0,#1
	CMP R0,#0
	BEQ EXIT
	MOV R3,R3,LSL #4
	MOV R2,R2,LSR #1
	B CONVERT
	
STOP
	B STOP

SRC DCD 97

	AREA dseg,DATA,READWRITE
DST DCD 0

	END