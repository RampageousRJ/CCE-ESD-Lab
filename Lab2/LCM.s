	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA myCode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R0,=Num1
	LDR R1,=Num2
	LDR R2,[R0]
	LDR R3,[R1]
	LDR R9,=DST
	EXPORT LOOP
	
LOOP 
	CMP R2,R3
	BEQ FIND_LCM
	BHI DECREMENT_R2
	BLO DECREMENT_R3
	
DECREMENT_R2
	SUB R2,R2,R3
	B LOOP
	
DECREMENT_R3
	SUB R3,R3,R2
	B LOOP
	
FIND_LCM
	MOV R5,R2
	LDR R2,[R0]
	LDR R3,[R1]
	MUL R4,R2,R3
	MOV R0,#0
	
DIVIDE 
	SUB R4,R4,R5
	ADD R0,R0,#1
	CMP R4,#0
	BNE DIVIDE
	STR R0,[R9]
	
STOP
	B STOP

Num1 DCD 0x6
Num2 DCD 0x9

	AREA data1,DATA,READWRITE
DST DCD 0

	END