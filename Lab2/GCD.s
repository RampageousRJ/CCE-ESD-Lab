	AREA RESET,DATA,READONLY
	EXPORT __Vectors
	
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA myCode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	LDR R0,=Num1
	LDR R1,=Num2
	LDR R2,[R0]
	LDR R3,[R1]
	LDR R9,=DST
	EXPORT LOOP
	
LOOP 
	CMP R2,R3
	BEQ ENDING
	BHI DECREMENT_R2
	BLO DECREMENT_R3
	
DECREMENT_R2
	SUB R2,R2,R3
	EXPORT LOOP
	
DECREMENT_R3
	SUB R3,R3,R2
	EXPORT LOOP
	
ENDING
	STR R2,[R9]
	
STOP
	B STOP

Num1 DCD 36
Num2 DCD 27

	AREA data1,DATA,READWRITE
DST DCD 0

	END